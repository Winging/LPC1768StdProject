# Keil uVision project LPC1768.uvproj, settings and files
target LPC1768High (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1768 +hex
  AfterMake: fromelf --bin   ./Obj/@L.axf  --output=./Bins/high.bin
  c flags: Optim=4 OneElfS=1
  c include: ..\NXPLibraries\CMSIS\CM3\CoreSupport;..\NXPLibraries\CMSIS\CM3\DeviceSupport\NXP\LPC17xx;..\NXPLibraries\include;..\NXPLibraries\source;..\UCOS;..\UCOS\uC-CONF;..\UCOS\uCOS-VIEW;..\UCOS\uCOS-II;..\UCOS\uC-CPU;..\UCOS\uCOS-II\Source;..\USER;..\uip;..\lpc17xx_port
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x7fa0
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ../NXPLibraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../NXPLibraries/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Startup
    ../NXPLibraries/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group User
    ../USER/: main.c App.c AppTcpIP.c AppGlobal.c
  group UserLib
    ../userlib/: RTCTime.c IAP.c AppDebug.c
  group Doc
    ../: readme.txt history.txt
  group uC-OS-II/Port
    ../UCOS/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-OS-II/Source
    ../UCOS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../UCOS/uC-CONF/: OS_AppHooks.c
  group UIP/Port
    ../lpc17xx_port/: clock-arch.c emac.c
  group UIP/Source
    ../uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c
  group NXPDrivers
    ../NXPLibraries/source/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_emac.c lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_rtc.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_i2c.c lpc17xx_wdt.c lpc17xx_adc.c
target LPC1768Low (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LPC1768 +hex
  AfterMake: fromelf --bin   ./Obj/@L.axf  --output=./Bins/low.bin
  c flags: Optim=4 OneElfS=1
  c include: ..\NXPLibraries\CMSIS\CM3\CoreSupport;..\NXPLibraries\CMSIS\CM3\DeviceSupport\NXP\LPC17xx;..\NXPLibraries\include;..\NXPLibraries\source;..\UCOS;..\UCOS\uC-CONF;..\UCOS\uCOS-VIEW;..\UCOS\uCOS-II;..\UCOS\uC-CPU;..\UCOS\uCOS-II\Source;..\USER;..\uip;..\userlib;..\lpc17xx_port
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x7fa0
  memory RVCT10: RAM 0x2007c000 size 0x8000
